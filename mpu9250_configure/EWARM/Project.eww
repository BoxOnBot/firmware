<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\mpu9250_configure.ewp</path>
  </project>
  <batchBuild />
</workspace>
